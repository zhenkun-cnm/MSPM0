# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6240000::V6.24::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "C:\ti\mspm0_sdk_2_10_00_04\tools\keil\syscfg.bat '$P' empty.syscfg"
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../;..\..\..\..\mspm0_sdk_2_10_00_04\source\third_party\CMSIS\Core\Include;..\..\..\..\mspm0_sdk_2_10_00_04\source;..\..\..\Middleware\FreeRTOS\include;..\..\..\Middleware\FreeRTOS\portable\GCC\ARM_CM0;..\..\..\APP\inc;..\..\..\Device\inc;..\port\inc;..\..\..\Algorithm\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: C:\ti\mspm0_sdk_2_10_00_04\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
  group Middleware/Freertos/port
    ../../../Middleware/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middleware/Freertos/Core
    ../../../Middleware/FreeRTOS/portable/GCC/ARM_CM0/: port.c portasm.c
    ../../../Middleware/FreeRTOS/portable/MemMang/: heap_4.c
  group App/Src
    ../../../APP/src/: app_button.c app_encoder.c app_init.c app_led.c app_flash.c app_tft.c app_tb6612.c app_motor_encoder.c app_ins_cmd.c app_nav.c app_path.c app_drive_mode.c app_gray.c app_stack_monitor.c app_test1.c
  group App/IMU RT
    ../../../APP/src/: app_imu.c app_ins.c app_motion.c app_gray_line.c
  group Dev/Src
    ../../../Device/src/: dev_menu.c
  group Port/Src
    ../port/src/: port_button.c port_encoder.c port_led.c port_log.c port_system.c port_flash.c port_tft.c port_tb6612.c port_motor_encoder.c port_motor_encoder2.c port_hardfault.c port_uart_rx.c port_gray.c
  group Port/IMU RT
    ../port/src/: port_imu.c port_lis3mdl.c
  group Algorithm/Src
    ../../../Algorithm/src/: imu_ekf.c imu_math.c imu_madgwick.c imu_ekf_light.c imu_filter.c imu_complementary.c imu_ahrs9.c
